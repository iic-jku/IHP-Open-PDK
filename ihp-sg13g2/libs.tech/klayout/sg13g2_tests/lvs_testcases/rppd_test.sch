v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {iopin.sym} 310 -410 3 0 {name=p2 lab=r2}
C {iopin.sym} 310 -350 1 0 {name=p1 lab=r1}
C {sg13g2_pr/rppd.sym} 310 -380 0 0 {name=R1
w=0.5e-6
l=0.5e-6
model=rppd
body=sub!
spiceprefix=X
b=0
m=1
}
