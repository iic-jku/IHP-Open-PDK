v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
P 4 1 190 -390 {}
N 200 -180 200 -160 {lab=a1}
N 200 -100 200 -80 {lab=b1}
C {iopin.sym} 200 -180 3 0 {name=p4 lab=a1}
C {iopin.sym} 200 -80 1 0 {name=p5 lab=b1}
C {sg13g2_pr/cap_cmim.sym} 200 -130 0 0 {name=C1
model=cap_cmim
w=7.0e-6
l=7.0e-6
m=1
spiceprefix=X}
